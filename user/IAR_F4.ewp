# IAR project IAR_F4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\drivers; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\CMSIS\Device\ST\STM32F4xx; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32F4xx_StdPeriph_Driver; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM4F; ..\sys; ..\app; ..\drivers\FATFS; ..\drivers\PICLIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOS\include; ..\app
  ILINK.IlinkOutputFile: IAR_F4.out
  ILINK.IlinkIcfFile: ..\EWARM\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: usart_cmd.c user_clock.c user_Debug_Info.c user_imgprocess.c user_showpic.c user_task.c
  group CMSIS
    ../EWARM/: startup_stm32f40_41xxx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group drivers
    ../drivers/: bsp_ili9341.c bsp_key.c bsp_led.c bsp_ov2640.c bsp_sccb.c bsp_sdio_sdcard.c
  group FatFs
    ../drivers/FATFS/option/: cc936.c
    ../drivers/FATFS/: diskio.c ff.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group PicLib
    ../drivers/PICLIB/: tjpgd.c
  group sys
    ../sys/: dcmi.c exit.c systick.c usart.c
  group user
    ./: main.c stm32f4xx_it.c
